## contrib/board/acme/at91sam9x5_arietta/arietta_128m_uboot_defconfig
```kconfig
CONFIG_AT91SAM9X5_ARIETTA=y
CONFIG_RAM_128MB=y
CONFIG_SDCARD=y
CONFIG_DEBUG=y
CONFIG_THUMB=y
```
